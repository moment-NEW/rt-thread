# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00050000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00008000) XRAM2(0x38000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __STDC_LIMIT_MACROS, USE_HAL_DRIVER, RT_USING_ARMLIBC, STM32H723xx, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC
  c include: ..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\posix\io\epoll;..\..\..\components\finsh;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\smp_call;..\..\..\components\libc\posix\io\poll;packages\stm32h7_hal_driver-latest\Inc;..\..\..\libcpu\arm\common;board;board\CubeMX_Config\Inc;..\..\..\include;..\..\..\libcpu\arm\cortex-m7;applications\ws2812;..\libraries\HAL_Drivers\drivers;..\..\..\components\drivers\include;..\..\..\components\drivers\include;applications;..\..\..\components\drivers\include;..\..\..\components\net\utest;..\..\..\components\drivers\include;packages\stm32h7_cmsis_driver-latest\Include;..\..\..\components\drivers\phy;..\libraries\HAL_Drivers\drivers\config;packages\CMSIS-Core-latest\Include;.;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;packages\stm32h7_hal_driver-latest\Inc\Legacy;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\HAL_Drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x8000
  memory RVCT7: RAM 0x38000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_dma.c drv_gpio.c drv_spi.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group STM32H7-CMSIS
    packages/stm32h7_cmsis_driver-latest/Source/Templates/: system_stm32h7xx.c
    packages/stm32h7_cmsis_driver-latest/Source/Templates/arm/: startup_stm32h723xx.s
  group STM32H7-HAL
    packages/stm32h7_hal_driver-latest/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_qspi.c
  group WS2812
    applications/ws2812/: ws2812.c
